# Keil uVision project sumo-car.uvproj, settings and files
target sumo-car (MCS-51)
  device: STC12C5A60S2 STC
  cpu: IRAM(0-0xFF) XRAM(0-0x3FF) IROM(0-0xEFFF) CLOCK(45000000) MODP2
  output: sumo-car +hex
  c flags: Optimize=8 SizeSpeed=1
  group user
    ./user/: main.c UART.c stdtype.h UART.h ADC.c ADC.h PCA.c HC-SR04.c
